# Keil uVision project nebula_master_401.uvprojx, settings and files
target nebula_master_401 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F401RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x18000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: nebula_master_401 +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe  --bin -o  ./bin/T9W_MCU_0.40.bin  ./nebula_master_401/nebula_master_401.axf
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F401xE
  c misc: --C99
  c include: ../Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CustomHID/Inc;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;..\Device_Driver\flash;..\Device_Driver\oled;..\Device_Driver\RGB_LED;..\APP;..\Device_Driver\EMR;..\Device_Driver\RTC;..\Lib;..\Device_Driver\BUTTON;..\Device_Driver\NRF518XX;..\Device_Driver\EM9203;..\Device_Driver\BATTERY;..\Device_Driver\PAGE_DET;..\Device_Driver\wifi_3080B;..\Device_Driver\WIFI_API;..\Device_Driver\WIFI_UART;..\Middlewares\ST\Third_Party\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\Middlewares\ST\Third_Party\FreeRTOS\Source\portable\MemMang;..\Middlewares\ST\Third_Party\FreeRTOS\Source\include;..\Middlewares\ST\Third_Party\FreeRTOS\Source\CMSIS_RTOS
  library: MicroLIB
  memory RVCT4: ROM 0x8020000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x18000
  link misc: --diag_suppress=L6329
  group Application/User
    ../Src/: main.c stm32f4xx_hal_msp.c stm32f4xx_it.c
    ../Inc/: mxconstants.h config.h
  group APP
    ../APP/: display.c note_manager.c gather_position.c Application_Main_Thread.c server.c input_event.c Status_Machin.c ble_client.c dfu.c usb_client.c product_test.c wifi_client.c
  group Lib
    ../Lib/: ex_interupt_callback.c debug_log.c Time_interupt_callback.c power_manager.c device_info.c misc.c cpu_a.asm
  group Device_Driver
    ../APP/: usb_controler.c
    ../Device_Driver/oled/: oled.c
    ../Device_Driver/flash/: norflash.c
    ../Device_Driver/RTC/: EXT_RTC.c
    ../Device_Driver/EMR/: General_Emr.c
    ../Device_Driver/NRF518XX/: nrf51822.c
    ../Device_Driver/BUTTON/: mmi.c
    ../Device_Driver/BATTERY/: battery.c
    ../Device_Driver/PAGE_DET/: page_detect.c
    ../Device_Driver/wifi_3080B/: ewm3080b.c
    ../Device_Driver/WIFI_API/: wifi_api.c
    ../Device_Driver/WIFI_UART/: wifi_uart.c
  group Usb_User
    ../Src/: usbd_desc.c usbd_conf.c usb_device.c usbd_custom_hid_if.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_ioreq.c usbd_ctlreq.c usbd_core.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CustomHID/Src/: usbd_customhid.c
  group Middlewares/FreeRTOS
    ../Middlewares/ST/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ../Middlewares/ST/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/ST/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../Middlewares/ST/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_iwdg.c stm32f4xx_hal_i2c.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_pcd.c stm32f4xx_ll_usb.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_pwr.c stm32f4xx_hal_cortex.c stm32f4xx_hal_adc.c stm32f4xx_hal.c stm32f4xx_hal_dma.c stm32f4xx_hal_gpio.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Application/MDK-ARM
    ./: startup_stm32f401xe.s
software components: CMSIS:CORE 4.3.0
