<?xml version="1.0" encoding="UTF-8" standalone="no" ?>
<ProjectWorkspace xmlns:xsi="http://www.w3.org/2001/XMLSchema-instance" xsi:noNamespaceSchemaLocation="project_mpw.xsd">

  <SchemaVersion>1.0</SchemaVersion>

  <Header>### uVision Project, (C) Keil Software</Header>

  <WorkspaceName>WorkSpace</WorkspaceName>

  <project>
    <PathAndName>.\nebula_master_401\MDK-ARM\nebula_master_401.uvprojx</PathAndName>
    <NodeIsActive>1</NodeIsActive>
    <NodeIsExpanded>1</NodeIsExpanded>
  </project>

  <project>
    <PathAndName>.\nebula_mater_boot\MDK-ARM\nebula_master_boot.uvprojx</PathAndName>
  </project>

  <Sle7>
    <Apps>
      <bAna>0</bAna>
      <nLevel>0</nLevel>
    </Apps>
    <Apps>
      <bAna>0</bAna>
      <nLevel>0</nLevel>
    </Apps>
    <Apps>
      <bAna>0</bAna>
      <nLevel>0</nLevel>
    </Apps>
    <Apps>
      <bAna>0</bAna>
      <nLevel>0</nLevel>
    </Apps>
    <Apps>
      <bAna>0</bAna>
      <nLevel>0</nLevel>
    </Apps>
    <Apps>
      <bAna>0</bAna>
      <nLevel>0</nLevel>
    </Apps>
    <ExecApp></ExecApp>
    <CfgApp></CfgApp>
    <bHex>0</bHex>
    <bList>0</bList>
    <buGlb>0</buGlb>
    <bCase>0</bCase>
    <szMisc></szMisc>
  </Sle7>

</ProjectWorkspace>
